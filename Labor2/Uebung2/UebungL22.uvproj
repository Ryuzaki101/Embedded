# Keil uVision project UebungL22.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2368 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: UebungL22
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2300_asm.s UART_GetChar.s UART_init.s UART_LoopBack_ASM.s UART_PutChar.s
